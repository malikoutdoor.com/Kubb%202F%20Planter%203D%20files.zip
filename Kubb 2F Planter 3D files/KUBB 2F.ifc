Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T16:38:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 16:38:43 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{A4E829D9-31FB-48DE-A5E9-79114D843306}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 16:38:42 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 16:38:42 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 16:38:42 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0FIAR025 - GRANITO - 339 Lt, Fioreria KUBB 2F:0FIAR025 - GRANITO - 339 Lt:146264
In: 0 - Piano Terra
Type - Material: GRANITO
Type - Altro - Categoria: Modelli generici; Nome famiglia: Fioreria KUBB 2F
Type - Dati identità - BIM Name: KUBB 2F - 339 L; BIM Object Type: FIORIERE - PLANTERS; Code: 0FIAR025; Designer: BELLITALIA DESIGN; Family Name: KUBB; Nome del tipo: 0FIAR025 - GRANITO - 339 Lt; URL Eng: https://www.bellitalia.net/en/products/planters/kubb-planters/; URL Ita: https://www.bellitalia.net/prodotti/fioriere/kubb-planters/
Type - Dimensioni - Dimensions: 2000 mm X 650 mm X 440 mm
Type - Generale - Descrizione Tecnica Famiglia: "fioriera a sezione rettangolare modulare mod. “KUBB 2F”, costituita da una fioriera monolitica dotata di un dispositivo di riserva d’acqua integrato che garantisce un giusto grado di umidità del terreno evitando che tutta l’acqua immessa all’interno si disperda."; Descrizione Tecnica per Codice: FIORIERA KUBB 2F IN GRANITO (COLORE A SCELTA) SABBIATO CON CERCHI SUPERIORI SPAZZOLATI VERNICE ANTIDECADIMENTOFIORIERA KUBB 2F IN GRANITO (COLORE A SCELTA) SABBIATO CON BORDI SUPERIORI SPAZZOLATI VERNICIATURA ANTI-DEGRADO; Fissaggio: Appoggio; Fixings: Freestanding; Technical Description Family: "modular rectangular section planter mod. “KUBB 2F”, consisting of a monolithic planter equipped with a built-in water reserve device that guarantees the right degree of humidity in the soil, avoiding that all the water introduced inside is dispersed."; Technical Description for Article: KUBB 2F PLANTER IN GRANITO (COLOR TO BE CHOSEN) SANDBLASTED WITH BRUSHED UPPER RIMS ANTI-DECAY VARNISH
Type - Materiali e finiture - MATERIALE FIORIERA: GRANITO; Materiale Principale: Granito Bianco; Materiale Secondario: Granito; Primary Material: Reconstituted White Granite; Secondary Material: Reconstituted Granite
Type - Meccanica - Weight ( kg): 615 Kg
Pset_BuildingElementProxyCommon - Reference: 0FIAR025 - GRANITO - 339 Lt
Altro - Famiglia: Fioreria KUBB 2F: 0FIAR025 - GRANITO - 339 Lt; Famiglia e tipo: Fioreria KUBB 2F: 0FIAR025 - GRANITO - 339 Lt; ID tipo: Fioreria KUBB 2F: 0FIAR025 - GRANITO - 339 Lt; Tipo: Fioreria KUBB 2F: 0FIAR025 - GRANITO - 339 Lt
Dimensioni - Area: 2.62213 m2; Volume: 0.157285 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
